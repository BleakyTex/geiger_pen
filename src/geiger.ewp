# IAR project geiger.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152K4 STM8L152K4
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x10
  General.GenHeapSize: 0x1000
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: geiger.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: asmmain.s
  group func
    func/: display.inc init.inc mode_switch.inc rate_update.inc state_load.inc state_reset.inc state_save.inc
